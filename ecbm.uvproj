# Keil uVision project ecbm.uvproj, settings and files
target STC8 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ecbm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ECBM_LIB;.\device;.\device\new_test;.\device\proj
  group USER
    ./: STARTUP.A51 main.c DS1302.C
  group LIB_LIST
    ./ECBM_LIB/: ecbm_core.h gpio.h power.h uart.h exti.h timer.h eeprom.h spi.h soft_spi.h iic.h soft_iic.h adc.h cmp.h mdu16.h pca.h pwm.h ecbm_reg.h lcm.h
    ./: ringq.c
  group ECBM_LIB
    ./ECBM_LIB/: ecbm_core.c gpio.c power.c uart.c exti.c timer.c eeprom.c spi.c soft_spi.c iic.c soft_iic.c adc.c cmp.c pca.c pwm.c lcm.c
