# Keil uVision project ecbm.uvproj, settings and files
target STC8 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ecbm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ECBM_LIB;.\device;.\device\new_test;.\device\proj
  group USER
    ./: STARTUP.A51 main.c
  group LIB_LIST
    ./ECBM_LIB/: ecbm_core.h gpio.h power.h uart.h exti.h timer.h eeprom.h spi.h soft_spi.h iic.h soft_iic.h adc.h cmp.h mdu16.h it.h pca.h pwm.h ecbm.h
  group ECBM_LIB
    ./ECBM_LIB/: ecbm_core.c gpio.c power.c uart.c exti.c timer.c eeprom.c spi.c soft_spi.c iic.c soft_iic.c adc.c cmp.c mdu16.c it.c pca.c
  group DEVICE
    ./device/: at24cxx.c
